# Keil uVision project Two_s_Com.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Two_s_Com
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Two_s.asm
